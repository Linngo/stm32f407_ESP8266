# Keil uVision project temp.uvproj, settings and files
target temp (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: temp +hex
  c flags: Optim=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\ESP12F;..\FWLIB\inc;..\HARDWARE\TIMER;..\HARDWARE\USART;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\MALLOC;..\HARDWARE\DMA
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group ESP12F
    ../ESP12F/: common.c wifista.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_usart.c stm32f4xx_tim.c stm32f4xx_syscfg.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_dma.c
  group HARDWARE
    ../HARDWARE/USART/: wifiusart.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/DMA/: dma.c
  group SYSTEM
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../MALLOC/: malloc.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
